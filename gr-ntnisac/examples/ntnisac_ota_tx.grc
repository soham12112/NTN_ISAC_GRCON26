options:
  parameters:
    author: NTN ISAC prototype
    category: '[ntnisac]'
    comment: |-
      TX LAPTOP. Waveform file -> emulated LEO pass -> USRP.

      Run the receive flowgraph on the other laptop with the SAME epoch and t_start.
      The two variables at the top left are the only things that must match.

      The LEO channel is applied digitally before the DAC (handoff section 2), so
      what leaves the antenna already carries the pass's Doppler, Doppler rate and
      delay walk. Nothing about the emulation changes going over the air.

      Power: at 2478 MHz under FCC part 15.247 this is a digital modulation system,
      licence-free to 30 dBm with a 6 dBi antenna. A B200 gives about 10 dBm here.
      tx_iq is scaled to RMS 0.1 with 10.6 dB of peak-to-average, so amp above ~2.5
      clips the DAC - and clipping is a nonlinearity the receiver's reference does
      not contain, so it quietly ruins every sensing measurement downstream.
    description: File -> LEO channel -> USRP, GPS-disciplined
    generate_options: no_gui
    id: ntnisac_ota_tx
    output_language: python
    realtime_scheduling: 'True'
    run_options: run
    title: NTN ISAC over the air - TX laptop
  states: {}

blocks:
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: From config.json. Do not change alone.
    value: 7.68e6
  states: {}
- name: mcr
  id: variable
  parameters:
    comment: Master clock rate. 32e6 gives a decimation of 4.1667 which UHD approximates silently, putting a fractional resampler in a chain whose whole point is delay accuracy. 30.72e6 gives exactly 4.
    value: 30.72e6
  states: {}
- name: rf_freq
  id: variable
  parameters:
    comment: 2.4 GHz ISM, above Wi-Fi channel 11 (which tops out at 2473) and below the band edge. Survey the local band first.
    value: 2.478e9
  states: {}
- name: wf_dir
  id: variable
  parameters:
    comment: 'Anchored at $NTN_ROOT, not the working directory: GRC runs a flowgraph from its own folder.'
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "wf_ota")
  states: {}
- name: traj_dir
  id: variable
  parameters:
    comment: Trajectory directory.
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "traj_ota")
  states: {}
- name: t_start
  id: variable
  parameters:
    comment: 'Trajectory time of the first transmitted sample. 300 is closest approach, where the range rate passes through zero: the easy epoch to bring a link up on. 500 is where the emulated drone sits at 640 m of excess path and is the one the demo uses.'
    value: '300.0'
  states: {}
- name: epoch
  id: variable
  parameters:
    comment: MUST MATCH THE RECEIVER. Absolute GPS second at which the first sample is emitted. 0 means start immediately, which gives up the shared time base - use gr/flowgraphs/ota_tx.py to pick one.
    value: '0.0'
  states: {}
- name: clock_src
  id: variable
  parameters:
    comment: Set to "internal" to run free and measure the clock-offset floor instead of eliminating it - handoff section 2's framing, which stays available on purpose.
    value: '"internal"'
  states: {}
- name: dev_serial
  id: variable
  parameters:
    comment: Set this to the transmitting B210 serial. Two radios on one bench and an unqualified device string is a coin toss.
    value: '""'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: TX gain, dB.
    value: '70.0'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: amp
  id: variable
  parameters:
    comment: Scalar before the DAC. Above ~2.5 clips.
    value: '1.0'
  states: {}
- name: tau_bias
  id: variable
  parameters:
    comment: Constant delay that keeps the interpolator's read pointer causally behind its write pointer. The receiver must use the same number.
    value: '40.0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 'repeat=True: the file is exactly 20 ms, one SSB period, so it loops at a frame boundary.'
    file: wf_dir + '/tx_iq.cf32'
    type: complex
    repeat: 'True'
  states: {}
- name: ntnisac_leo_channel_0
  id: ntnisac_leo_channel
  parameters:
    comment: 'The emulated pass. 16-tap sinc: measured 14.2 MS/s against a 7.68 MS/s requirement, so it clears real time with margin.'
    traj_csv: traj_dir + '/traj.csv'
    fs: samp_rate
    fc: rf_freq
    r_nominal: '-1.0'
    tau_bias: tau_bias
    delay_line: '131072'
    interp_taps: '16'
    t_start: t_start
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    type: fc32
    dev_addr: dev_serial
    dev_args: ''''''
    sync: unknown pps
    start_time: epoch
    clock_rate: 30.72e6
    clock_source0: clock_src
    time_source0: clock_src
    samp_rate: samp_rate
    center_freq0: rf_freq
    gain0: gain
    ant0: antenna
    lo_source0: ''
    len_tag_name: ''
  states: {}

connections:
- [blocks_file_source_0, '0', ntnisac_leo_channel_0, '0']
- [ntnisac_leo_channel_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
