options:
  parameters:
    author: NTN ISAC prototype
    category: '[ntnisac]'
    comment: |-
      RX LAPTOP. USRP -> two sensing paths -> ZMQ -> dashboard.

      epoch and t_start MUST MATCH the transmit flowgraph.

      There are two targets and they need different processing, so there are two
      paths on the same samples.

        OTA Sense        the PHYSICAL object between the radios. At 4.5 MHz the
                         delay cell is 66.6 m and an object a metre off a 5 m
                         baseline has 0.39 m of bistatic excess path - 0.006 of a
                         cell - so it is inside the direct path's own cell and no
                         reachable bandwidth separates them. It is measured in
                         Doppler alone, after CLEAN removes the direct path.
                         Measured: a -40 dB co-delay echo reads +0.8 dB against a
                         target-absent run without cancellation and +54.0 dB with it.

        SSB Coarse +     the EMULATED drone at 640 m of excess path, with exact
        Grid Sense       commanded truth. Unchanged from the conducted flowgraph.

      Running both is the point: a target whose answer is known exactly validates
      the chain, and a target that is really there proves it is not validating
      itself.

      One caveat, and it is the reason to bother with the GPS antennas. Grid Sense
      and SSB Coarse track the pass from ephemeris and have no clock-offset
      estimator, so they need the two references disciplined. Measured in
      simulation, 1 ppm of offset takes Grid Sense's peak-to-noise from 91 dB to
      62 dB and its detections become nonsense. OTA Sense estimates the offset
      itself and is immune, because a common carrier error cancels between the
      direct path and the target. So: free-running gets you the physical target,
      GPS-locked gets you both.
    description: USRP -> physical + emulated sensing -> ZMQ
    generate_options: no_gui
    id: ntnisac_ota_rx
    output_language: python
    realtime_scheduling: 'True'
    run_options: run
    title: NTN ISAC over the air - RX laptop
  states: {}

blocks:
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: From config.json.
    value: 7.68e6
  states: {}
- name: mcr
  id: variable
  parameters:
    comment: Exactly 4x decimation at 7.68 MS/s.
    value: 30.72e6
  states: {}
- name: rf_freq
  id: variable
  parameters:
    comment: Must match the transmitter.
    value: 2.478e9
  states: {}
- name: wf_dir
  id: variable
  parameters:
    comment: 'The receiver needs the bundle too: ref_mask and tx_grid are what make payload-aided sensing possible, and the reference it reconstructs from them IS the reference channel. A B200 has one receive port, so there is no second antenna to take one from.'
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "wf_ota")
  states: {}
- name: traj_dir
  id: variable
  parameters:
    comment: Same trajectory the TX is playing.
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "traj_ota")
  states: {}
- name: t_start
  id: variable
  parameters:
    comment: MUST MATCH THE TRANSMITTER.
    value: '300.0'
  states: {}
- name: epoch
  id: variable
  parameters:
    comment: MUST MATCH THE TRANSMITTER.
    value: '0.0'
  states: {}
- name: clock_src
  id: variable
  parameters:
    comment: 'See the flowgraph comment: "internal" still gives the physical target but not the emulated one.'
    value: '"internal"'
  states: {}
- name: dev_serial
  id: variable
  parameters:
    comment: Set this to the receiving B210 serial.
    value: '""'
  states: {}
- name: gain
  id: variable
  parameters:
    comment: 'RX gain, dB. Set it so the direct path sits 15-20 dB below full scale: the ADC has to hold the direct path and the target at once, and clipping the strong one destroys the weak one.'
    value: '40.0'
  states: {}
- name: antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: tau_bias
  id: variable
  parameters:
    comment: Must match the transmitter. On real RF the extra fixed delay through cable, filters and pipeline is measured once and added here - handoff section 9's V4 calibration constant. OTA Sense converges on it and reports it.
    value: '40.0'
  states: {}
- name: n_frames
  id: variable
  parameters:
    comment: 5 frames = 100 ms sensing dwell.
    value: '5'
  states: {}
- name: micro_frames
  id: variable
  parameters:
    comment: '1 s micro-Doppler dwell. It has to be this long: 100 ms gives 5 Hz Doppler cells against a 7 rev/s blade''s 7 Hz line spacing, and an unresolved rotation rate comes out confident and wrong. Measured, 1 s recovers 7.00 and 11.00 exactly.'
    value: '50'
  states: {}
- name: variant
  id: variable
  parameters:
    comment: The research claim. "reference-only" is the comparison.
    value: '"payload-aided"'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    type: fc32
    dev_addr: dev_serial
    dev_args: ''''''
    sync: unknown pps
    start_time: epoch
    clock_rate: 30.72e6
    clock_source0: clock_src
    time_source0: clock_src
    samp_rate: samp_rate
    center_freq0: rf_freq
    gain0: gain
    ant0: antenna
    lo_source0: ''
    dc_offs_enb0: ''
    dc_offs0: '0'
    iq_imbal_enb0: ''
    iq_imbal0: '0'
  states: {}
- name: ntnisac_ota_sense_0
  id: ntnisac_ota_sense
  parameters:
    comment: 'The physical target. Blackman-Harris across slow time: Hann''s -31 dB sidelobe is the same number as the direct path''s own skirt at the target''s Doppler, and here the target is in the same delay cell so that skirt IS the detection floor.'
    wf_dir: wf_dir
    traj_dir: traj_dir
    n_frames: n_frames
    t_start: t_start
    tau_bias: tau_bias
    variant: variant
    pad: '2'
    stride: '1'
    window: '"blackmanharris"'
    gps_locked: clock_src == 'gpsdo'
    n_clean: '2'
    clean_delay_ns: '200.0'
    clean_doppler_hz: '15.0'
    micro_frames: micro_frames
    micro_every: '10'
    rot_min_hz: '3.0'
    rot_max_hz: '40.0'
    snr_db: '10.0'
    cfo_max_hz: 12e3
    publish_profile: 'True'
    link_metrics: 'True'
  states: {}
- name: ntnisac_ssb_coarse_0
  id: ntnisac_ssb_coarse
  parameters:
    comment: 'Stage 1 for the emulated target. Needs the GPSDOs: it has no clock-offset estimator.'
    wf_dir: wf_dir
    traj_dir: traj_dir
    n_frames: n_frames
    t_start: t_start
    tau_bias: tau_bias
    pad: '2'
    stride: '1'
    gate_widen: '3.0'
    sigma_accel: '3.0'
    min_snr_db: '12.0'
    exclude_delay_cells: '1.0'
    notch_cells: '2.0'
  states: {}
- name: ntnisac_grid_sense_0
  id: ntnisac_grid_sense
  parameters:
    comment: Stage 2. Extra variant maps the SAME dwell, which is the only way two maps are a comparison.
    wf_dir: wf_dir
    traj_dir: traj_dir
    n_frames: n_frames
    t_start: t_start
    tau_bias: tau_bias
    variant: variant
    pad: '2'
    stride: '2'
    n_false_alarms: '1.0'
    notch_cells: '2.0'
    exclude_delay_cells: '1.0'
    min_det_snr_db: '6.0'
    min_renyi_bits: '0.0'
    max_fragmentation: '-1.0'
    suppress_sidebands: 'True'
    publish_maps: 'True'
    extra_variants: '"reference-only"'
    link_metrics: 'True'
    map_doppler_hz: '250.0'
    clutter_locus: 'True'
    clutter_max_range_m: '250.0'
    clutter_guard_bins: '1.0'
    clean_components: '1'
    clean_delay_cells: '1.0'
    clean_doppler_hz: '20.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: 'Raw capture for the offline campaign. Disable if not wanted: 7.68 MS/s is 61 MB per second.'
    file: '"data/capture.cf32"'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    comment: Physical target, per dwell.
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    comment: Micro-Doppler (1 s) and emulated-target sensing.
    address: tcp://127.0.0.1:5556
    timeout: '100'
  states: {}
- name: zeromq_pub_msg_sink_2
  id: zeromq_pub_msg_sink
  parameters:
    comment: Sync state, for a lock indicator.
    address: tcp://127.0.0.1:5557
    timeout: '100'
  states: {}

connections:
- [uhd_usrp_source_0, '0', ntnisac_ota_sense_0, '0']
- [uhd_usrp_source_0, '0', ntnisac_ssb_coarse_0, '0']
- [uhd_usrp_source_0, '0', ntnisac_grid_sense_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [ntnisac_ota_sense_0, ota, zeromq_pub_msg_sink_0, in]
- [ntnisac_ota_sense_0, micro, zeromq_pub_msg_sink_1, in]
- [ntnisac_ota_sense_0, state, zeromq_pub_msg_sink_2, in]
- [ntnisac_ssb_coarse_0, coarse, ntnisac_grid_sense_0, coarse]
- [ntnisac_grid_sense_0, refine, ntnisac_ssb_coarse_0, refine]
- [ntnisac_grid_sense_0, sense, zeromq_pub_msg_sink_1, in]

metadata:
  file_format: 1
