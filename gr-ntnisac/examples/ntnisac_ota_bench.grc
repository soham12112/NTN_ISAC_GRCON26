options:
  parameters:
    author: NTN ISAC prototype
    category: '[ntnisac]'
    comment: |-
      BENCH. The whole over-the-air receive path, with no radio.

      Run this first. It needs nothing but the data/ directory, it runs on one
      laptop, and it exercises the identical blocks the two over-the-air flowgraphs
      use - so a number that comes out here is a number the receive path produces.

          File Source -> LEO Channel -> Es/N0 Noise -> LEO Truth -+-> OTA Sense
                                                                  +-> SSB Coarse
                                                                  +-> Grid Sense

      The rotating object that would physically sit between the two radios is the
      fourth path in data/traj_bench, injected by tools/add_bench_target.py. That is
      not a special case: a rotating scatterer is a range history like any other and
      the channel block already takes any number of paths, so it plays through the
      same C++ block the transmit flowgraph uses. Regenerate it with

          $NTN_PY tools/add_bench_target.py --rot-hz 7 --gain-db -30

      What to look at. Set esn0_db and blade echo wherever you like, then compare the
      two numbers OTA Sense prints per dwell: the direct path's peak-to-noise, and
      how far CLEAN took it down. Then watch the "micro" messages, which arrive once
      per second because that is what it takes to resolve a 7 rev/s line spacing -
      at the 100 ms sensing dwell the Doppler cell is 5 Hz and the rate comes out a
      harmonic.

      The instructive experiment is to open tools/add_bench_target.py's --gain-db
      down to -40 and compare Grid Sense with OTA Sense. Grid Sense still finds the
      emulated drone at 640 m, because it is resolved in delay. Nothing finds the
      rotating object without CLEAN, because it is 0.006 of a delay cell from the
      direct path and what hides it is not noise.
    description: The OTA receive path, simulated end to end
    generate_options: no_gui
    id: ntnisac_ota_bench
    output_language: python
    run_options: run
    title: NTN ISAC over-the-air bench (no radio)
  states: {}

blocks:
- name: esn0_db
  id: variable
  parameters:
    comment: Es/N0 per occupied subcarrier. The point of the bench is that lowering this is NOT what hides the rotating target.
    value: '45.0'
  states: {}
- name: n_frames
  id: variable
  parameters:
    comment: 5 frames = 100 ms sensing dwell.
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: From config.json.
    value: 7.68e6
  states: {}
- name: t_start
  id: variable
  parameters:
    comment: 'Closest approach: the range rate passes through zero, so this is the benign epoch. Try 500 to put the emulated drone at 640 m of excess path, which is where it has the most separation.'
    value: '300.0'
  states: {}
- name: tau_bias
  id: variable
  parameters:
    value: '40.0'
  states: {}
- name: traj_dir
  id: variable
  parameters:
    comment: traj_ota plus a rotating target as a fourth path, made by tools/add_bench_target.py. Use traj_bench_all to keep the emulated clutter and drone as well.
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "traj_bench")
  states: {}
- name: variant
  id: variable
  parameters:
    comment: The research claim. Try "reference-only" for the comparison.
    value: '"payload-aided"'
  states: {}
- name: wf_dir
  id: variable
  parameters:
    comment: Anchored at $NTN_ROOT, so it does not matter where GRC runs the flowgraph from.
    value: os.path.join(os.environ.get("NTN_ROOT", "."), "data", "wf_ota")
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: 20 ms, one SSB period, so repeat loops at a frame boundary.
    file: wf_dir + '/tx_iq.cf32'
    repeat: 'True'
    type: complex
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: ntnisac_esn0_noise_0
  id: ntnisac_esn0_noise
  parameters:
    comment: Calibrated against the occupied subcarriers.
    esn0_db: esn0_db
    n_fft: '512'
    n_occ: '300'
    seed: '0'
    settle: '768000'
    signal_rms: '-1.0'
  states: {}
- name: ntnisac_grid_sense_0
  id: ntnisac_grid_sense
  parameters:
    comment: Stage 2, the emulated drone. Stride 2 because it costs more than its dwell in Python.
    clutter_guard_bins: '1.0'
    clutter_locus: 'True'
    clutter_max_range_m: '250.0'
    clean_components: '1'
    clean_delay_cells: '1.0'
    clean_doppler_hz: '20.0'
    exclude_delay_cells: '1.0'
    extra_variants: '""'
    link_metrics: 'False'
    map_doppler_hz: '250.0'
    max_fragmentation: '-1.0'
    min_det_snr_db: '6.0'
    min_renyi_bits: '0.0'
    n_false_alarms: '1.0'
    n_frames: n_frames
    notch_cells: '2.0'
    pad: '2'
    publish_maps: 'False'
    stride: '2'
    suppress_sidebands: 'True'
    t_start: t_start
    tau_bias: tau_bias
    traj_dir: traj_dir
    variant: variant
    wf_dir: wf_dir
  states: {}
- name: ntnisac_leo_channel_0
  id: ntnisac_leo_channel
  parameters:
    comment: 'Four paths: direct, static clutter, the emulated drone, and the rotating object.'
    delay_line: '131072'
    fc: 2.478e9
    fs: samp_rate
    interp_taps: '16'
    r_nominal: '-1.0'
    t_start: t_start
    tau_bias: tau_bias
    traj_csv: traj_dir + '/traj.csv'
  states: {}
- name: ntnisac_leo_truth_0
  id: ntnisac_leo_truth
  parameters:
    comment: Commanded truth on the sample clock, for scoring.
    fs: samp_rate
    period_ms: '100.0'
    port: truth
    t_start: t_start
    tau_bias: tau_bias
    traj_dir: traj_dir
  states: {}
- name: ntnisac_msg_print_0
  id: ntnisac_msg_print
  parameters:
    comment: NOT Message Debug. Payloads are JSON in a u8vector, which Message Debug prints as several thousand decimal bytes.
    tag: '"ota"'
    verbose: 'False'
  states: {}
- name: ntnisac_msg_print_1
  id: ntnisac_msg_print
  parameters:
    comment: Rotation rate, once per second.
    tag: '"micro"'
    verbose: 'False'
  states: {}
- name: ntnisac_msg_print_2
  id: ntnisac_msg_print
  parameters:
    comment: The emulated target, resolved in delay.
    tag: '"drone"'
    verbose: 'False'
  states: {}
- name: ntnisac_ota_sense_0
  id: ntnisac_ota_sense
  parameters:
    cfo_max_hz: 12e3
    clean_delay_ns: '200.0'
    clean_doppler_hz: '15.0'
    comment: The rotating object. Sync, CLEAN, micro-Doppler.
    gps_locked: 'False'
    link_metrics: 'True'
    micro_every: '10'
    micro_frames: '50'
    n_clean: '2'
    n_frames: n_frames
    pad: '2'
    publish_profile: 'True'
    rot_max_hz: '40.0'
    rot_min_hz: '3.0'
    snr_db: '10.0'
    stride: '1'
    t_start: t_start
    tau_bias: tau_bias
    traj_dir: traj_dir
    variant: variant
    wf_dir: wf_dir
    window: '"blackmanharris"'
  states: {}
- name: ntnisac_ssb_coarse_0
  id: ntnisac_ssb_coarse
  parameters:
    comment: Stage 1, the emulated drone.
    exclude_delay_cells: '1.0'
    gate_widen: '3.0'
    min_snr_db: '12.0'
    n_frames: n_frames
    notch_cells: '2.0'
    pad: '2'
    sigma_accel: '3.0'
    stride: '1'
    t_start: t_start
    tau_bias: tau_bias
    traj_dir: traj_dir
    wf_dir: wf_dir
  states: {}

connections:
- [blocks_file_source_0, '0', ntnisac_leo_channel_0, '0']
- [ntnisac_esn0_noise_0, '0', ntnisac_leo_truth_0, '0']
- [ntnisac_grid_sense_0, refine, ntnisac_ssb_coarse_0, refine]
- [ntnisac_grid_sense_0, sense, ntnisac_msg_print_2, in]
- [ntnisac_leo_channel_0, '0', ntnisac_esn0_noise_0, '0']
- [ntnisac_leo_truth_0, '0', ntnisac_grid_sense_0, '0']
- [ntnisac_leo_truth_0, '0', ntnisac_ota_sense_0, '0']
- [ntnisac_leo_truth_0, '0', ntnisac_ssb_coarse_0, '0']
- [ntnisac_ota_sense_0, micro, ntnisac_msg_print_1, in]
- [ntnisac_ota_sense_0, ota, ntnisac_msg_print_0, in]
- [ntnisac_ssb_coarse_0, coarse, ntnisac_grid_sense_0, coarse]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
